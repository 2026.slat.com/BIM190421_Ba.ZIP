Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, QuantityTakeOffAddOnView]
File name: 0001
Time: 2019-07-30T14:00:04
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170223_1515(x64) - Exporter 18.0.0.420 - Alternate UI 18.0.0.420
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Jul 30 14:00:04 2019 * Host: Piranha * Database: C:\Users\datBIM\AppData\Local\Temp\{7DC8B5DE-9693-4BB0-8C1D-47DFEC975D89}\ifc * Database version: 5507 * Database creation date: Tue Jul 30 14:00:02 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Jul 30 14:00:03 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Jul 30 14:00:03 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Nom du projet; Phase: Etat du projet

# IfcSite, Default
RefLatitude: 48, 51, 23, 999633; RefLongitude: 2, 21, 3, 553905; RefElevation: 0 mm
Autre - Adresse du projet: Entrer l'adresse ici; Catégorie: Informations sur le projet; Date de fin du projet: Date de fin; Etat du projet: Etat du projet; Nom du client: Propriétaire; Nom du projet: Nom du projet; Numéro de projet: 0001

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Autre - Catégorie: Informations sur le projet; Adresse du projet: Entrer l'adresse ici; Date de fin du projet: Date de fin; Etat du projet: Etat du projet; Nom du client: Propriétaire; Nom du projet: Nom du projet; Numéro de projet: 0001

# IfcBuildingStorey, Niveau 1
LongName: Niveau 1; Elevation: 0 mm
Graphismes(Type) - Couleur: 0; Epaisseur des lignes: 1; Motif des lignes: Centre; Symbole: Marqueur de niveau - Cercle: Marqueur de niveau - Cercle; Valeur par défaut du symbole à l'extrémité 1: no; Valeur par défaut du symbole à l'extrémité 2: yes
Données d'identification(Type) - Nom du type: Pointe 8 mm
Contraintes(Type) - Base de l'élévation: Point de base du projet
Autre(Type) - Catégorie: Niveaux; Nom de la famille: Niveau
Autre - Catégorie: Niveaux; Famille: Niveau: Pointe 8 mm; Famille et type: Niveau: Pointe 8 mm; ID du type: Niveau: Pointe 8 mm; Type: Niveau: Pointe 8 mm
Contraintes - Elévation: 0 mm
Cotes - Hauteur de calcul: 0 mm
Données d'identification - Etage de bâtiment: yes; Nom: Niveau 1; Structure: no

# IfcBuildingElementProxy: SYNAPS 24V 3E IP SPACE BOX, SYNAPS 24V 3E IP SPACE BOX:SYNAPS 24V 3E IP SPACE BOX:137635
In: Niveau 1
Type - Autre - Catégorie: Equipement électrique; datBIM.Classe electrique (Electrical class): 1; datBIM.Code datBIM entité: 89431734; datBIM.Code produit SLAT (Id SlatEntityCode): 89431734; datBIM.Conformite ATEX (ATEX compliance): Non (No); datBIM.Consommation electrique (Primary current): 1.5 A; datBIM.Couleur dominante (Dominant color): Gris RAL 7035 (Grey RAL 7035); datBIM.Courant maximal d'utilisation (Maximal output current): 2.3 A; datBIM.Degre d'etancheite IP (Protection class IP): IP65; datBIM.Description longue entité: <p> <img title="SYNAPS_PoE_SPACEBOX_closed_HD.jpg" src="https://admin.datbim.com/media/mid/1/23238.jpg" alt="" width="286" height="237" data-idmedia="23238" /></p><p><em>Ref. : 89431734<br /></em></p><p>SYNAPS-IP est un Micro-UPS DC communicant dédié aux applications vidéo-protection outdoor alimentées en 12 VDC ou 24 V DC. En cas de coupure de courant, il assure la continuité de service des équipements qu?il alimente grâce à la fonction secours LiFePO4 intégrée / SYNAPS IP is a communicating DC Micro-UPS specifically designed for 12 or 24 Vdc-powered outdoor video surveillance applications. In the event of power failure, it ensures continuity of service for the equipment it powers with the integrated LiFePO4 backup function.</p>; datBIM.Designation technique (Technical designation): AES, EAE, EAES; datBIM.Duree de la garantie (Length of warranty): 2 ans; datBIM.Duree de vie previsionnelle (Expected life expectancy): 10 ans; datBIM.Duree de vie previsionnelle de reconditionnement (Expected life of refurbishment): 10 ans; datBIM.Fonction generique (Generic function): Alimentation électrique secourue (Emergency power supply); datBIM.Hauteur (Height): 300 mm; datBIM.Hauteur hors tout (Height overall): 332.5 mm; datBIM.Id: datBIM:384109; datBIM.Largeur (Wide): 400 mm; datBIM.Largeur hors tout (Wide overall): 400 mm; datBIM.Libellé entité: SYNAPS 24V 3E IP SPACE BOX; datBIM.Longueur (Length): 150 mm; datBIM.Longueur hors tout (Length overall): 176.6 mm; datBIM.Marque commerciale (Commercial brand): SLAT; datBIM.Matiere de l'enveloppe (Envelope material): Polycarbonate; datBIM.Mode de communication (Communication mode): 2 Ports Ethernet 10_100 Mbps (2 Ethernet ports 10_100 Mbps); datBIM.Nombre de sorties d'alimentation (Number of power supply outputs): 1; datBIM.Poids (Weight): 5.1; datBIM.Point de fixation (Mounting point): 4; datBIM.Produit repartis dans plusieurs enveloppes (Product divided into several envelopes): Non (No); datBIM.Puissance (Output power): 55 W; datBIM.Qualification d'installateur : NF S 61-932 - Règles d’installation (Installer qualification : NF S 61-932 - Installation rules): Recommande (Recommanded); datBIM.Qualification d'installateur : NF S 61-970 - Règles d'installation des systèmes de détection incendie (Installer qualification : Installation rules for fire detection systems): Recommande (Recommanded); datBIM.Qualification d'installateur : R7 (Installer qualification : R7): Recommande (Recommanded); datBIM.Qualification du mainteneur : Annexe B NF S 61-933 - SDI (Qualification of the maintainer : Appendix B NF S 61-933 - SDI): Recommande (Recommanded); datBIM.Qualification du mainteneur : Annexe J NF S 61-933 Alimentation (Qualification of the maintainer : Appendix J NF S 61-933 Power supply): Recommande (Recommanded); datBIM.Qualification du mainteneur : Annexe L NF S 61-933 Exploitant (Qualification of the maintainer : Appendix L NF S 61-933 Operator): Recommande (Recommanded); datBIM.Rendement energetique (Energy efficiency): 90; datBIM.Site WEB du fournisseur: www.slat.com; datBIM.Substance visee par REACH_DEEE (Substance covered by REACH_DEEE): Non (No); datBIM.Temperature d'utilisation (Operating temperature): -5 à +50 °C; datBIM.Tension de fonctionnement [Min-Max] (Mains voltage [Min-Max]): 97,8-264,5 V; datBIM.Tension nominale de sortie (Rated output voltage): 24 V; datBIM.Tenue aux chocs IK (Protection class IK): IK10; datBIM.Type de liaison (Type of link): Filaire (Wired); datBIM.Type d'installation (Mounting type): Mural (Wall-mounted); Nom de la famille: SYNAPS 24V 3E IP SPACE BOX
Type - Données d'identification - Fabricant: SLAT; Nom du type: SYNAPS 24V 3E IP SPACE BOX
Pset_BuildingElementProxyCommon - Reference: SYNAPS 24V 3E IP SPACE BOX
Pset_ManufacturerTypeInformation - Manufacturer: SLAT
Autre - Famille: SYNAPS 24V 3E IP SPACE BOX: SYNAPS 24V 3E IP SPACE BOX; Famille et type: SYNAPS 24V 3E IP SPACE BOX: SYNAPS 24V 3E IP SPACE BOX; ID du type: SYNAPS 24V 3E IP SPACE BOX: SYNAPS 24V 3E IP SPACE BOX; Type: SYNAPS 24V 3E IP SPACE BOX: SYNAPS 24V 3E IP SPACE BOX
Contraintes - Décalage: 0 mm; Hôte: Niveau : Niveau 1; Niveau: Niveau: Niveau 1; Se déplace avec les éléments voisins: no
Cotes - Surface: 0.28595 m2; Volume: 0.0183735 m3
Données d'identification - Identifiant: 1
Electricité - Charges - Charge apparente - Phase A: 0 W; Charge apparente - Phase B: 0 W; Charge apparente - Phase C: 0 W; Charge totale connectée: 0 W; Demande de charge totale estimée: 0 W; Facteur de charge totale: 1
Phase de construction - Phase de création: Phase 1
